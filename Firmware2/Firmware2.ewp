# IAR project Firmware2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: D:\Study\Project_ARM\Firmware2\CMSIS\Include; D:\Study\Project_ARM\Firmware2\MKL46Z; D:\Study\Project_ARM\Firmware2\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Firmware2.srec
  ILINK.IlinkOutputFile: Firmware2.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source
    ./: ADC.c ADC.h Firmware2.c GPIO.c GPIO.h Middleware.c Middleware.h PIT.c PIT.h Port.c Port.h UART.c UART.h
  group startup
    MKL46Z/: startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
