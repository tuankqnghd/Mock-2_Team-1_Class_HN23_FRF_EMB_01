# IAR project LED_Blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: D:\Study\Project_ARM\LED_Blink\CMSIS\Include; D:\Study\Project_ARM\LED_Blink\MKL46Z; D:\Study\Project_ARM\LED_Blink\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LED_Blink.srec
  ILINK.IlinkOutputFile: LED_Blink.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source
    ./: LedBlinking.c
  group startup
    MKL46Z/: startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
